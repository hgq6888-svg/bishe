# Keil uVision project HZ.uvprojx, settings and files
target HZ (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HZ +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --locale=chinese
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LCD;..\HARDWARE\KEY;..\MALLOC;..\USMART;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\FWLIB\inc;..\My_lin\24CXX;..\My_lin\HGQ_AHT20;..\My_lin\HGQ_BH1750;..\My_lin\HGQ_ESP8266;..\My_lin\HGQ_HCSR501;..\My_lin\HGQ_RC522;..\My_lin\HGQ_USART;..\My_lin\IIC;..\My_lin\TOUCH;..\My_lin\HGQ_UI_SEAT;..\My_lin\HGQ_UI_DASH;..\My_lin\HGQ_V15310x;..\My_lin\HGQ_UI;..\My_lin\LED
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_dma.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group README
    ../: readme.txt
  group My_lin
    ../My_lin/24CXX/: 24cxx.c
    ../My_lin/HGQ_AHT20/: hgq_aht20.c hgq_myiic2.c
    ../My_lin/HGQ_BH1750/: hgq_bh1750.c hgq_myiic3.c
    ../My_lin/HGQ_ESP8266/: hgq_esp8266.c
    ../My_lin/HGQ_HCSR501/: hgq_hcsr501.c
    ../My_lin/HGQ_RC522/: hgq_rc522.c
    ../My_lin/HGQ_USART/: hgq_usart.c
    ../My_lin/IIC/: myiic.c
    ../My_lin/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../My_lin/HGQ_V15310x/: hgq_vl53l0x.c
    ../My_lin/HGQ_UI/: hgq_ui.c
    ../My_lin/LED/: led.c
